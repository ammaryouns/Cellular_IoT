# IAR project Frey.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32TG11B120F128GM32 SiliconLaboratories EFM32TG11B120F128GM32
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: EFM32TG11B120F128GM32; DEBUG_EFM
  ICCARM.CCIncludePath2: CMSIS; EFM32TG11B\Include; emlib\inc; micrium_os; micrium_os\bsp\siliconlabs\generic\include; micrium_os\cfg; System\inc; emdrv\inc; emdrv\config
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: EFM32TG11B120F128GM32; DEBUG_EFM
  AARM.AUserIncludes: CMSIS; EFM32TG11B\Include; emlib\inc; micrium_os; micrium_os\bsp\siliconlabs\generic\include; micrium_os\cfg
  OBJCOPY.OOCOutputFile: Frey.bin
  ILINK.IlinkOutputFile: Frey.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group EFM32TGB11
    EFM32TG11B/Source/: startup_efm32tg11b.s system_efm32tg11b.c
  group EmDrv
    emdrv/src/: dmadrv.c gpiointerrupt.c nvm.c nvm_config.c nvm_hal.c rtcdriver.c sleep.c spidrv.c uartdrv.c ustimer.c
  group EmLib
    emlib/src/: em_assert.c em_cmu.c em_core.c em_emu.c em_gpio.c em_ldma.c em_leuart.c em_rtc.c em_rtcc.c em_usart.c em_wdog.c
  group Micrium_OS/Common
    micrium_os/common/source/auth/: auth.c
    micrium_os/common/source/collections/: bitmap.c map.c slist.c
    micrium_os/common/source/clk/: clk.c clk_cmd.c
    micrium_os/common/source/common/: common.c
    micrium_os/common/source/kal/: kal_kernel.c
    micrium_os/common/source/lib/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    micrium_os/common/source/platform_mgr/: platform_mgr.c
    micrium_os/common/source/rtos/: rtos_err_str.c
  group Micrium_OS/Common/BSP
    micrium_os/bsp/siliconlabs/generic/source/: bsp_cpu.c bsp_os.c
  group Micrium_OS/Common/CPU
    micrium_os/ports/source/iar/: armv6m_cpu_a.asm
    micrium_os/ports/source/generic/: armv6m_v7m_cpu_int.c
    micrium_os/cpu/source/: cpu_core.c
  group Micrium_OS/Kernel
    micrium_os/ports/source/iar/: armv6m_os_cpu_a.asm armv6m_os_cpu_c.c
    micrium_os/kernel/source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_mon.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group System
    System/src/: Cellular.c CellularATCommands.c DataFlash.c Event.c ExtCommunication.c FileCommit.c GPS.c jsmn.c main.c SPI_Comm.c SysTask.c Timer.c
